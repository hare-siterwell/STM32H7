# Keil uVision project STM32V7.uvprojx, settings and files
target STM32V7 (6160000::V6.16::ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: release +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,STM32H743xx,USE_HAL_DRIVER
  c include: ../Core/Inc;             ../Drivers/STM32H7xx_HAL_Driver/Inc;             ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;             ../Drivers/CMSIS/Include;             ../Components/uCOS-III/uC-CONFIG;             ../Components/uCOS-III/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM;             ../Components/uCOS-III/uC-CPU;             ../Components/uCOS-III/uC-LIB;             ../Components/uCOS-III/uC-OS3/Ports/ARM-Cortex-M/ARMv7-M/ARM;             ../Components/uCOS-III/uC-OS3/Source;             ../Components/BSP;             ../Components/Devices/TFTLCD;             ../Components/Devices/STEP;   ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c bdma.c dma.c usart.c spi.c tim.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_exti.c stm32h7xx_ll_gpio.c stm32h7xx_ll_bdma.c stm32h7xx_ll_rcc.c stm32h7xx_ll_utils.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_dma.c stm32h7xx_ll_lpuart.c stm32h7xx_ll_usart.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group BSP
    ../Components/BSP/: bsp_app.c bsp_delay.c bsp_lcd.c bsp_led.c bsp_spi.c bsp_usart.c
  group Device
    ../Components/Devices/TFTLCD/: tftlcd.c
    ../Components/Devices/STEP/: step.c
  group uCOS-III/uC-CPU
    ../Components/uCOS-III/uC-CPU/: cpu_core.c
    ../Components/uCOS-III/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../Components/uCOS-III/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu_a.asm
  group uCOS-III/uC-LIB
    ../Components/uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uCOS-III/uC-OS3/Ports
    ../Components/uCOS-III/uC-OS3/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../Components/uCOS-III/uC-OS3/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu_a.asm
  group uCOS-III/uC-OS3/Source
    ../Components/uCOS-III/uC-OS3/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uCOS-III/uC-CONFIG
    ../Components/uCOS-III/uC-CONFIG/: cpu_cfg.h lib_cfg.h os_cfg.h os_cfg_app.h
